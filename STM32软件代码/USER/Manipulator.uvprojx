# Keil uVision project Manipulator.uvprojx, settings and files
target Manipulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Manipulator +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BSP;..\HARDWARE\KEY;..\CONTROLTASK\ROBOT;..\CONTROLTASK\KEYHANDER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\SMBUS;..\CONTROLTASK\SENSOR;..\HARDWARE\ULTRASONIC;..\CONTROLTASK\KALMAN;..\HARDWARE\OLED;..\CONTROLTASK\DISPLAY;..\HARDWARE\TIMER;..\HARDWARE\STEPPER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CONTROLTASK
    ../CONTROLTASK/ROBOT/: robot.c
    ../CONTROLTASK/KEYHANDER/: keyhander.c
    ../CONTROLTASK/SENSOR/: sensor.c
    ../CONTROLTASK/KALMAN/: KalmanFilter.c
    ../CONTROLTASK/DISPLAY/: display.c
  group HARDWARE
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SMBUS/: smbus.c
    ../HARDWARE/ULTRASONIC/: ultrasonic.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STEPPER/: stepper.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_tim.c
  group README
    ../: README.TXT
